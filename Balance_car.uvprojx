# Keil uVision project Balance_car.uvprojx, settings and files
target BalancingCar (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance_car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --locale=english
  c include: .\FWlib\Inc;.\CMSIS;.\FWlib\Src;.\user;.\user\Inc;.\user\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWlib
    ./FWlib/Src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group BSP
    ./user/Src/: bsp.c MPU6050.c oled.c ADC.c usart.c I2C.c ultrasonic.c motor.c led.c beep.c syn6288.c
  group SYS
    ./user/Src/: systick.c debug.c sys.c
  group USER
    ./user/Src/: main.c common.c communication.c display.c control.c dataflash.c manage.c
    ./user/: stm32f10x_it.c
software components: CMSIS:CORE 4.3.0
